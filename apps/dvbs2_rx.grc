options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: dvbs2_rx
    output_language: python
  states: {}

blocks:
- name: noise_power
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '1.2'
    value: '0.51'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: symbol_rate * 2
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: '6000000'
  states: {}
- name: analog_fastnoise_source_x_0
  id: analog_fastnoise_source_x
  parameters:
    amp: noise_power
    noise_type: analog.GR_GAUSSIAN
    samples: '8192'
    seed: '0'
    type: complex
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: decoded.ts
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: thefuryclip.ts
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: dtv_dvb_bbheader_bb_0
  id: dtv_dvb_bbheader_bb
  parameters:
    framesize2: FECFRAME_NORMAL
    rate3: C3_5
    rolloff: RO_0_20
    standard: STANDARD_DVBS2
  states: {}
- name: dtv_dvb_bbscrambler_bb_0
  id: dtv_dvb_bbscrambler_bb
  parameters:
    framesize2: FECFRAME_NORMAL
    rate3: C3_5
    standard: STANDARD_DVBS2
  states: {}
- name: dtv_dvb_bch_bb_0
  id: dtv_dvb_bch_bb
  parameters:
    framesize2: FECFRAME_NORMAL
    rate3: C3_5
    standard: STANDARD_DVBS2
  states: {}
- name: dtv_dvb_ldpc_bb_0
  id: dtv_dvb_ldpc_bb
  parameters:
    constellation: MOD_OTHER
    framesize2: FECFRAME_NORMAL
    rate3: C3_5
    standard: STANDARD_DVBS2
  states: {}
- name: dtv_dvbs2_interleaver_bb_0
  id: dtv_dvbs2_interleaver_bb
  parameters:
    constellation: MOD_8PSK
    framesize: FECFRAME_NORMAL
    rate1: C3_5
  states: {}
- name: dtv_dvbs2_modulator_bc_0
  id: dtv_dvbs2_modulator_bc
  parameters:
    constellation: MOD_8PSK
    framesize: FECFRAME_NORMAL
    interpolation: INTERPOLATION_OFF
    rate1: C3_5
  states: {}
- name: dvbs2rxx_bbdeheader_bb_0
  id: dvbs2rxx_bbdeheader_bb
  parameters:
    framesize1: FECFRAME_NORMAL
    framesize2: FECFRAME_NORMAL
    rate1: C1_2
    rate2: C1_3
    rate3: C3_5
    rate4: C1_5_MEDIUM
    rate5: C1_4
    standard: STANDARD_DVBS2
  states: {}
- name: dvbs2rxx_bbdescrambler_bb_0
  id: dvbs2rxx_bbdescrambler_bb
  parameters:
    framesize1: FECFRAME_NORMAL
    framesize2: FECFRAME_NORMAL
    rate1: C1_2
    rate2: C1_3
    rate3: C3_5
    rate4: C1_5_MEDIUM
    rate5: C1_4
    standard: STANDARD_DVBS2
  states: {}
- name: dvbs2rxx_bch_decoder_bb_0
  id: dvbs2rxx_bch_decoder_bb
  parameters:
    framesize1: FECFRAME_NORMAL
    framesize2: FECFRAME_NORMAL
    outputmode: OM_MESSAGE
    rate1: C1_2
    rate2: C1_3
    rate3: C3_5
    rate4: C1_5_MEDIUM
    rate5: C1_4
    standard: STANDARD_DVBS2
  states: {}
- name: dvbs2rxx_ldpc_decoder_cb_0
  id: dvbs2rxx_ldpc_decoder_cb
  parameters:
    constellation1: MOD_QPSK
    constellation2: MOD_8PSK
    framesize1: FECFRAME_NORMAL
    framesize2: FECFRAME_NORMAL
    infomode: INFO_OFF
    outputmode: OM_MESSAGE
    rate1: C1_2
    rate2: C1_3
    rate3: C3_5
    rate4: C1_5_MEDIUM
    rate5: C1_4
    standard: STANDARD_DVBS2
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: int-mod
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: ldpc-bch
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: int-mod
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: ldpc-bch
  states: {}

connections:
- [analog_fastnoise_source_x_0, '0', blocks_add_xx_0, '0']
- [blocks_add_xx_0, '0', blocks_throttle_0_0, '0']
- [blocks_add_xx_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_file_source_0, '0', dtv_dvb_bbheader_bb_0, '0']
- [blocks_throttle_0_0, '0', dvbs2rxx_ldpc_decoder_cb_0, '0']
- [dtv_dvb_bbheader_bb_0, '0', dtv_dvb_bbscrambler_bb_0, '0']
- [dtv_dvb_bbscrambler_bb_0, '0', dtv_dvb_bch_bb_0, '0']
- [dtv_dvb_bch_bb_0, '0', dtv_dvb_ldpc_bb_0, '0']
- [dtv_dvb_ldpc_bb_0, '0', dtv_dvbs2_interleaver_bb_0, '0']
- [dtv_dvbs2_interleaver_bb_0, '0', virtual_sink_0, '0']
- [dtv_dvbs2_modulator_bc_0, '0', blocks_add_xx_0, '1']
- [dvbs2rxx_bbdeheader_bb_0, '0', blocks_file_sink_0, '0']
- [dvbs2rxx_bbdescrambler_bb_0, '0', dvbs2rxx_bbdeheader_bb_0, '0']
- [dvbs2rxx_bch_decoder_bb_0, '0', dvbs2rxx_bbdescrambler_bb_0, '0']
- [dvbs2rxx_ldpc_decoder_cb_0, '0', virtual_sink_1, '0']
- [virtual_source_0, '0', dtv_dvbs2_modulator_bc_0, '0']
- [virtual_source_1, '0', dvbs2rxx_bch_decoder_bb_0, '0']

metadata:
  file_format: 1
